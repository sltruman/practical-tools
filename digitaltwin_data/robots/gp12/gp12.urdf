Commit message: 抓手问题

File: digitaltwin_data/robots/gp12/gp12.urdf (robot description, URDF)
Before this commit: robot motoman, 8 links, 7 joints
Joints:
- joint jointEE: origin xyz=0.100 0 0 rpy=3.1415926 -1.570796 0 -> xyz=0.100 0 0 rpy=-3.1415926 -1.570796 0
