Commit message: 标定测试

File: practistyle/data/cameras/camera3d/camera3d.urdf (robot description, URDF)
Before this commit: robot canera3d, 1 links, 0 joints
Links:
- link base: mass 4.0 -> 0.1
