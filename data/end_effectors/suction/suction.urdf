Commit message: 阶段提交

File: data/end_effectors/suction/suction.urdf (robot description, URDF)
Before this commit: robot universal_robot, 3 links, 2 joints
Links:
- link ee: geometry collision mesh filename=link1.obj; visual mesh filename=link1.obj
