Commit message: 阶段提交

File: data/cameras/camera3d/camera3d.urdf (robot description, URDF)
Before this commit: robot canera3d, 1 links, 0 joints
Links:
- link base: geometry collision mesh filename=camera3d.obj scale=1 1 1; visual mesh filename=camera3d.obj scale=1 1 1
